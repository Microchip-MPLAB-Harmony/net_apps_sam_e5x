# IAR project tcpip_tcp_server.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME54P20A Microchip ATSAME54P20A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: HAVE_CONFIG_H; WOLFSSL_IGNORE_FILE_WARN; __PIC32C__
  ICCARM.CCIncludePath2: ..\src\config\sam_e54_xpro_iar\library; ..\src\config\sam_e54_xpro_iar\library\tcpip\src; ..\src\config\sam_e54_xpro_iar\library\tcpip\src\common; ..\src; ..\src\config\sam_e54_xpro_iar; ..\src\packs\ATSAME54P20A_DFP; ..\src\packs\CMSIS\CMSIS\Core\Include; ..\src\packs\CMSIS; ..\src\third_party\wolfssl; ..\src\third_party\wolfssl\wolfssl
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: tcpip_tcp_server.hex
  ILINK.IlinkOutputFile: sam_e54_xpro_iar.out
  ILINK.IlinkIcfFile: ..\src\config\sam_e54_xpro_iar\flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HAVE_CONFIG_H; WOLFSSL_IGNORE_FILE_WARN; NDEBUG
  ICCARM.CCOptLevel: 3
  group Harmony3/Header Files
    ../src/: app.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar
    ../src/config/sam_e54_xpro_iar/: device.h system_config.h system_definitions.h user.h configuration.h device_cache.h toolchain_specifics.h definitions.h interrupts.h device_vectors.h config.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/peripheral/nvmctrl
    ../src/config/sam_e54_xpro_iar/peripheral/nvmctrl/: plib_nvmctrl.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/peripheral/tc
    ../src/config/sam_e54_xpro_iar/peripheral/tc/: plib_tc_common.h plib_tc0.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/peripheral/sercom/usart
    ../src/config/sam_e54_xpro_iar/peripheral/sercom/usart/: plib_sercom2_usart.h plib_sercom_usart_common.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/peripheral/evsys
    ../src/config/sam_e54_xpro_iar/peripheral/evsys/: plib_evsys.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/peripheral/port
    ../src/config/sam_e54_xpro_iar/peripheral/port/: plib_port.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/peripheral/clock
    ../src/config/sam_e54_xpro_iar/peripheral/clock/: plib_clock.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/peripheral/nvic
    ../src/config/sam_e54_xpro_iar/peripheral/nvic/: plib_nvic.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/peripheral/cmcc
    ../src/config/sam_e54_xpro_iar/peripheral/cmcc/: plib_cmcc.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/system
    ../src/config/sam_e54_xpro_iar/system/: sys_time_h2_adapter.h sys_random_h2_adapter.h system.h system_common.h system_module.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/system/time
    ../src/config/sam_e54_xpro_iar/system/time/: sys_time.h sys_time_definitions.h
    ../src/config/sam_e54_xpro_iar/system/time/src/: sys_time_local.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/system/int
    ../src/config/sam_e54_xpro_iar/system/int/: sys_int.h sys_int_mapping.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/system/cache
    ../src/config/sam_e54_xpro_iar/system/cache/: sys_cache.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/system/reset
    ../src/config/sam_e54_xpro_iar/system/reset/: sys_reset.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/system/debug
    ../src/config/sam_e54_xpro_iar/system/debug/: sys_debug.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/system/command
    ../src/config/sam_e54_xpro_iar/system/command/: sys_command.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/system/console
    ../src/config/sam_e54_xpro_iar/system/console/: sys_console.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/driver
    ../src/config/sam_e54_xpro_iar/driver/: driver.h driver_common.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/driver/ethphy
    ../src/config/sam_e54_xpro_iar/driver/ethphy/: drv_ethphy.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/driver/ethphy/src
    ../src/config/sam_e54_xpro_iar/driver/ethphy/src/: drv_ethphy_local.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/driver/ethphy/src/dynamic
    ../src/config/sam_e54_xpro_iar/driver/ethphy/src/dynamic/: drv_extphy_regs.h drv_extphy_ksz8091.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/driver/gmac
    ../src/config/sam_e54_xpro_iar/driver/gmac/: drv_gmac.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/driver/gmac/src
    ../src/config/sam_e54_xpro_iar/driver/gmac/src/: drv_gmac_local.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/driver/gmac/src/dynamic
    ../src/config/sam_e54_xpro_iar/driver/gmac/src/dynamic/: _gmac_dcpt_lists.h drv_gmac_lib.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/driver/miim
    ../src/config/sam_e54_xpro_iar/driver/miim/: drv_miim.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/driver/miim/src
    ../src/config/sam_e54_xpro_iar/driver/miim/src/: drv_miim_local.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/driver/miim/src/dynamic
    ../src/config/sam_e54_xpro_iar/driver/miim/src/dynamic/: drv_miim_mapping.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/library/tcpip
    ../src/config/sam_e54_xpro_iar/library/tcpip/: tcpip_common_ports.h tcpip_mac.h tcpip_mac_object.h tcpip_manager.h tcpip_heap.h tcpip_helpers.h ndp.h ipv4.h ipv6.h icmpv6.h dhcpv6.h arp.h udp.h tcp.h berkeley_api.h dhcp.h dhcps.h dhcp_server.h zero_conf_link_local.h zero_conf_multicast_dns.h dns.h dnss.h ftp.h ftpc.h icmp.h nbns.h ddns.h telnet.h smtp.h sntp.h http.h http_net.h snmp.h snmpv3.h tcpip_announce.h lldp.h smtpc.h igmp.h tftpc.h tftps.h tcpip_reboot.h iperf.h tcpip_commands.h tcpip.h tcpip_mac_bridge.h tcpip_ethernet.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/library/tcpip/src
    ../src/config/sam_e54_xpro_iar/library/tcpip/src/: tcpip_heap_alloc.h ndp_manager.h ndp_private.h ipv4_manager.h ipv4_private.h ipv6_manager.h ipv6_private.h icmp_manager.h icmpv6_manager.h arp_manager.h arp_private.h udp_manager.h udp_private.h tcp_manager.h tcp_private.h dhcp_manager.h dhcp_private.h dhcps_manager.h dhcps_private.h dhcp_server_manager.h dhcp_server_private.h zero_conf_helper.h zero_conf_link_local_private.h zero_conf_manager.h dns_manager.h dns_private.h dnss_manager.h dnss_private.h ftp_manager.h ftp_private.h ftpc_manager.h ftpc_private.h nbns_manager.h ddns_manager.h telnet_manager.h smtp_manager.h sntp_manager.h http_manager.h http_private.h http_net_manager.h http_net_private.h snmp_manager.h snmp_private.h snmpv3_private.h tcpip_announce_manager.h smtpc_manager.h smtpc_private.h igmp_manager.h igmp_private.h tftpc_manager.h tftpc_private.h tftps_manager.h tftps_private.h tcpip_reboot_manager.h iperf_manager.h tcpip_commands_manager.h hash_fnv.h link_list.h oahash.h tcpip_helpers_private.h tcpip_manager_control.h tcpip_module_manager.h tcpip_notify.h tcpip_packet.h tcpip_private.h tcpip_types.h berkeley_manager.h dhcpv6_manager.h dhcpv6_private.h lldp_manager.h lldp_private.h lldp_tlv.h tcpip_mac_bridge_manager.h tcpip_mac_bridge_private.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/library/tcpip/src/common
    ../src/config/sam_e54_xpro_iar/library/tcpip/src/common/: helpers.h sys_fs_shell.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/net_pres/pres
    ../src/config/sam_e54_xpro_iar/net_pres/pres/: net_pres.h net_pres_socketapi.h net_pres_socketapiconversion.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/osal
    ../src/config/sam_e54_xpro_iar/osal/: osal.h osal_definitions.h osal_impl_basic.h
  group Harmony3/Header Files/config/sam_e54_xpro_iar/crypto
    ../src/config/sam_e54_xpro_iar/crypto/: crypto.h
  group Harmony3/Header Files/packs/ATSAME54P20A_DFP
    ../src/packs/ATSAME54P20A_DFP/: same54p20a.h
  group Harmony3/Header Files/packs/ATSAME54P20A_DFP/component
    ../src/packs/ATSAME54P20A_DFP/component/: ac.h adc.h aes.h can.h ccl.h cmcc.h dac.h dmac.h dsu.h eic.h evsys.h freqm.h fuses.h gclk.h gmac.h hmatrixb.h i2s.h icm.h mclk.h nvmctrl.h osc32kctrl.h oscctrl.h pac.h pcc.h pdec.h pm.h port.h pukcc.h qspi.h ramecc.h rstc.h rtc.h sdhc.h sercom.h supc.h tc.h tcc.h trng.h usb.h wdt.h
  group Harmony3/Header Files/packs/ATSAME54P20A_DFP/instance
    ../src/packs/ATSAME54P20A_DFP/instance/: ac.h adc0.h adc1.h aes.h can0.h can1.h ccl.h cmcc.h dac.h dmac.h dsu.h eic.h evsys.h freqm.h fuses.h gclk.h gmac.h hmatrix.h i2s.h icm.h mclk.h nvmctrl.h osc32kctrl.h oscctrl.h pac.h pcc.h pdec.h pm.h port.h qspi.h ramecc.h rstc.h rtc.h sdhc0.h sdhc1.h sercom0.h sercom1.h sercom2.h sercom3.h sercom4.h sercom5.h sercom6.h sercom7.h supc.h tc0.h tc1.h tc2.h tc3.h tc4.h tc5.h tc6.h tc7.h tcc0.h tcc1.h tcc2.h tcc3.h tcc4.h trng.h usb.h wdt.h
  group Harmony3/Header Files/packs/ATSAME54P20A_DFP/pio
    ../src/packs/ATSAME54P20A_DFP/pio/: same54p20a.h
  group Harmony3/Header Files/packs/CMSIS/CMSIS/Core/Include
    ../src/packs/CMSIS/CMSIS/Core/Include/: cmsis_version.h cmsis_compiler.h cmsis_iccarm.h cmsis_gcc.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h core_cm4.h mpu_armv7.h cachel1_armv7.h
  group Harmony3/Header Files/wolfcrypt
    ../src/third_party/wolfssl/wolfssl/wolfcrypt/: arc4.h asn.h asn_public.h blake2-impl.h blake2-int.h blake2.h camellia.h chacha.h chacha20_poly1305.h cmac.h coding.h compress.h cpuid.h cryptocb.h curve25519.h curve448.h des3.h dh.h dsa.h ed25519.h ed448.h error-crypt.h fe_448.h fe_operations.h fips_test.h ge_448.h ge_operations.h hash.h hc128.h hmac.h idea.h integer.h logging.h md2.h md4.h md5.h memory.h mem_track.h misc.h mpi_class.h mpi_superclass.h pkcs11.h pkcs12.h pkcs7.h poly1305.h pwdbased.h rabbit.h random.h rc2.h ripemd.h rsa.h selftest.h sha3.h signature.h sp.h sp_int.h srp.h tfm.h visibility.h wc_encrypt.h wc_pkcs11.h wolfevent.h wolfmath.h settings.h aes.h sha.h sha256.h sha512.h wc_port.h ecc.h types.h
    ../src/third_party/wolfssl/wolfssl/: certs_test.h
  group Harmony3/Header Files/wolfcrypt/port
    ../src/third_party/wolfssl/wolfssl/wolfcrypt/port/pic32/: pic32mz-crypt.h CryptoLib_cf_pb.h CryptoLib_ClearFlags_pb.h CryptoLib_Comp_pb.h CryptoLib_CondCopy_pb.h CryptoLib_CRT_pb.h CryptoLib_Div_pb.h CryptoLib_ExpMod_pb.h CryptoLib_FastCopy_pb.h CryptoLib_Fill_pb.h CryptoLib_Fmult_pb.h CryptoLib_GCD_pb.h CryptoLib_GF2NEccAdd_pb.h CryptoLib_GF2NEccConv_pb.h CryptoLib_GF2NEccDbl_pb.h CryptoLib_GF2NEccMul_pb.h CryptoLib_GF2NEcDsa_pb.h CryptoLib_Hardware_pb.h CryptoLib_Headers_pb.h CryptoLib_JumpTable_pb.h CryptoLib_mapping_pb.h CryptoLib_PrimeGen_pb.h CryptoLib_Rc_pb.h CryptoLib_RedMod_pb.h CryptoLib_Rng_pb.h CryptoLib_SelfTest_pb.h CryptoLib_Services_pb.h CryptoLib_Smult_pb.h CryptoLib_Square_pb.h CryptoLib_Swap_pb.h CryptoLib_typedef_pb.h CryptoLib_ZpEccAddSub_pb.h CryptoLib_ZpEccAdd_pb.h CryptoLib_ZpEccConv_pb.h CryptoLib_ZpEccDbl_pb.h CryptoLib_ZpEccMul_pb.h CryptoLib_ZpEccQuickDualMul_pb.h CryptoLib_ZpEcDsa_pb.h crypt_aes_hw.h crypt_aes_hwInt.h crypt_aes_sam6149.h crypt_aes_u2238.h crypt_crya_saml11.h crypt_ecc_ba414e.h crypt_ecc_pukcl.h crypt_pukcl_definitions.h crypt_pukcl_functions.h crypt_rng_hw.h crypt_rsa_pukcl.h crypt_sha1_hw.h crypt_sha224_hw.h crypt_sha256_hw.h crypt_sha384_hw.h crypt_sha512_hw.h crypt_sha_hw.h crypt_sha_sam11105.h crypt_sha_sam6156.h crypt_tdes_hw.h crypt_tdes_hwInt.h crypt_tdes_sam6150.h crypt_wolfcryptcb.h
  group Harmony3/Source Files
    ../src/: app.c main.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar
    ../src/config/sam_e54_xpro_iar/: tasks.c initialization.c interrupts.c exceptions.c startup_iar.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/peripheral/nvmctrl
    ../src/config/sam_e54_xpro_iar/peripheral/nvmctrl/: plib_nvmctrl.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/peripheral/tc
    ../src/config/sam_e54_xpro_iar/peripheral/tc/: plib_tc0.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/peripheral/sercom/usart
    ../src/config/sam_e54_xpro_iar/peripheral/sercom/usart/: plib_sercom2_usart.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/peripheral/evsys
    ../src/config/sam_e54_xpro_iar/peripheral/evsys/: plib_evsys.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/peripheral/port
    ../src/config/sam_e54_xpro_iar/peripheral/port/: plib_port.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/peripheral/clock
    ../src/config/sam_e54_xpro_iar/peripheral/clock/: plib_clock.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/peripheral/nvic
    ../src/config/sam_e54_xpro_iar/peripheral/nvic/: plib_nvic.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/peripheral/cmcc
    ../src/config/sam_e54_xpro_iar/peripheral/cmcc/: plib_cmcc.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/library/tcpip/src
    ../src/config/sam_e54_xpro_iar/library/tcpip/src/: icmp.c tcp.c arp.c tcpip_commands.c ipv4.c tcpip_heap_alloc.c tcpip_heap_internal.c dhcp.c dns.c hash_fnv.c oahash.c tcpip_helpers.c tcpip_manager.c tcpip_notify.c tcpip_packet.c udp.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/library/tcpip/src/common
    ../src/config/sam_e54_xpro_iar/library/tcpip/src/: helpers.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/system
    ../src/config/sam_e54_xpro_iar/system/: sys_time_h2_adapter.c sys_random_h2_adapter.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/system/time
    ../src/config/sam_e54_xpro_iar/system/time/src/: sys_time.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/system/console
    ../src/config/sam_e54_xpro_iar/system/console/src/: sys_console_uart.h sys_console_uart_definitions.h sys_console_uart.c sys_console.c sys_console_local.h
  group Harmony3/Source Files/config/sam_e54_xpro_iar/system/int
    ../src/config/sam_e54_xpro_iar/system/int/src/: sys_int.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/system/cache
    ../src/config/sam_e54_xpro_iar/system/cache/: sys_cache.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/system/reset
    ../src/config/sam_e54_xpro_iar/system/reset/: sys_reset.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/system/command
    ../src/config/sam_e54_xpro_iar/system/command/src/: sys_command.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/system/debug
    ../src/config/sam_e54_xpro_iar/system/debug/src/: sys_debug_local.h sys_debug.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/driver/ethphy/src/dynamic
    ../src/config/sam_e54_xpro_iar/driver/ethphy/src/dynamic/: drv_ethphy.c drv_extphy_ksz8091.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/driver/gmac/src/dynamic
    ../src/config/sam_e54_xpro_iar/driver/gmac/src/dynamic/: drv_gmac.c drv_gmac_lib_samE5x.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/driver/miim/src/dynamic
    ../src/config/sam_e54_xpro_iar/driver/miim/src/dynamic/: drv_miim.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/stdio
    ../src/config/sam_e54_xpro_iar/stdio/: iar_monitor.c
  group Harmony3/Source Files/config/sam_e54_xpro_iar/crypto
    ../src/config/sam_e54_xpro_iar/crypto/src/: crypto.c
  group Harmony3/Source Files/wolfcrypt
    ../src/third_party/wolfssl/wolfssl/wolfcrypt/src/: arc4.c asm.c asn.c blake2b.c blake2s.c camellia.c chacha.c chacha20_poly1305.c cmac.c coding.c compress.c cpuid.c cryptocb.c curve25519.c curve448.c dh.c dsa.c ecc_fp.c ed25519.c ed448.c error.c fe_448.c fe_low_mem.c fe_operations.c ge_448.c ge_low_mem.c ge_operations.c hash.c hc128.c hmac.c idea.c integer.c logging.c md2.c md4.c md5.c memory.c pkcs12.c pkcs7.c poly1305.c pwdbased.c rabbit.c rc2.c ripemd.c rsa.c sha3.c signature.c sp_arm32.c sp_arm64.c sp_armthumb.c sp_c32.c sp_c64.c sp_cortexm.c sp_dsp32.c sp_int.c sp_x86_64.c srp.c tfm.c wc_dsp.c wc_encrypt.c wc_pkcs11.c wc_port.c wolfevent.c wolfmath.c aes.c des3.c random.c sha.c sha256.c sha512.c ecc.c
  group Harmony3/Source Files/wolfcrypt/port
    ../src/third_party/wolfssl/wolfssl/wolfcrypt/src/port/pic32/: pic32mz-crypt.c crypt_aes_sam6149.c crypt_aes_u2238.c crypt_ecc_ba414e.c crypt_ecc_pukcl.c crypt_pukcl_functions.c crypt_rng_sam6334.c crypt_rng_u2242.c crypt_rsa_pukcl.c crypt_sam_u2803.c crypt_sha1_sam11105.c crypt_sha1_sam6156.c crypt_sha224_sam11105.c crypt_sha224_sam6156.c crypt_sha256_sam11105.c crypt_sha256_sam6156.c crypt_sha384_sam6156.c crypt_sha512_sam6156.c crypt_tdes_sam6150.c crypt_wolfcryptcb.c
  group Harmony3/Linker File
    ../src/config/sam_e54_xpro_iar/: flash.icf
